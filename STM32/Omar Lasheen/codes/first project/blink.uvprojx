# Keil uVision project blink.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User Applications
    ./: main.c slave_main.c master_main.c imu.c esp_app.c encoder.c RPM.c IMU_0.c PWM_test.c Steering_angle.c test_led.c
  group User Libraries
    ./: RCC_INTERFACE.c RCC_INTERFACE.h RCC_PRIVATE.h RCC_CONFIG.h GPIO_config.h GPIO_interface.h GPIO_private.h GPIO_program.c PWM_INTERFACE.h PWM_PRIVATE.h PWM_CONFIG.h PWM_INTERFACE.c STK_config.h STK_private.h STK_program.c ADC_config.h ADC_interface.h ADC_program.c STK_interface.h USART_CONFIG.h USART_INTERFACE.c USART_INTERFACE.h USART_PRIVATE.h AFIO_config.h AFIO_interface.h AFIO_private.h AFIO_program.c SPI_config.h SPI_interface.h SPI_PROG.c BIT_MATH.h STD_TYPES.h SPI_PRIVATE.h DMA_REG.h I2C_config.h I2C_interface.h I2C_private.h DMA.c DMA_INTERFACE.h I2C_program.c CAN_CONFIG.h CAN_INTERFACE.c CAN_INTERFACE.h CAN_PRIVATE.h ESP8266_config.h ESP8266_interface.h ESP8266_private.h ESP8266_program.c EXTI_config.h EXTI_interface.h EXTI_private.h EXTI_program.c
    ./: NVIC_private.h NVIC_program.c NVIC_config.h NVIC_interface.h ADC_private.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
